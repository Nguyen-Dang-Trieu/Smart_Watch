# Keil uVision project smart_watch.uvprojx, settings and files
target smart_watch (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: smart_watch +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_FULL_LL_DRIVER,STM32F103xB,USE_HAL_DRIVER
  c include: ../Core/Inc;C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.6/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.6/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.6/Drivers/CMSIS/Include;../../driver/Delay;../../driver/FLASH_AT45DB161;..\..\middleware\freeRTOS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/ADMIN/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.6/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_gpio.c stm32f1xx_ll_spi.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group DriversLayer/FLASH
    ../../driver/Delay/: stm32f1xx_delay.c stm32f1xx_delay.h
    ../../driver/FLASH_AT45DB161/: AT45DB161D.c AT45DB161D.h AT45DB161D_cmds.h
  group MiddlewareLayer/freeRTOS
    ../../middleware/freeRTOS/: atomic.h croutine.c croutine.h event_groups.c event_groups.h FreeRTOS.h heap_4.c list.c list.h message_buffer.h port.c portable.h portmacro.h queue.c queue.h semphr.h stream_buffer.c stream_buffer.h task.h tasks.c timers.c timers.h FreeRTOSConfig.h deprecated_definitions.h
software components: CMSIS:CORE 5.6.0
